require postfix.inc

SRC_URI += "file://postfix-add-db6-support.patch"

SRC_URI[md5sum] = "c3277d05b78eaaf5955406bc7b6d2b9f"
SRC_URI[sha256sum] = "77f35574c78cf5ac468061c38037c4f858ead7554e2314e7760c30328f08591e"
